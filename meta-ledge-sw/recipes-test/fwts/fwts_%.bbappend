COMPATIBLE_HOST = "(i.86|x86_64|aarch64|powerpc64|arm).*-linux"

