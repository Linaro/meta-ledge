# Remove circular dependancy between native cmake and curl

DEPENDS_remove = "curl-native"
