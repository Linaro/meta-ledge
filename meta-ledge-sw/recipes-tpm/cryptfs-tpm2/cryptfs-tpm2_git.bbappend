FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"
SRC_URI += " file://fix_misspelling_of_TPM2_PT_TPM2_HR_PERSISTENT.patch"
