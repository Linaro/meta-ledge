SRC_URI = " \
    git://github.com/opencontainers/runc;branch=main;protocol=https \
    file://0001-Makefile-respect-GOBUILDFLAGS-for-runc-and-remove-re.patch \
    "
