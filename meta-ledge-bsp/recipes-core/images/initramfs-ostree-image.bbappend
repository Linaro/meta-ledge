# remove raw image generation for initramfs
IMAGE_FSTYPES_remove = "ledgeraw"
